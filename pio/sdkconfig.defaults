## pio/sdkconfig.defaults
```kconfig
# USB CDC on Boot (Serial over USB-C on ESP32-P4)
# CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
